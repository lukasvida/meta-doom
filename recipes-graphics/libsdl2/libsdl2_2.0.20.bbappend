PACKAGECONFIG += "alsa directfb pulseaudio"